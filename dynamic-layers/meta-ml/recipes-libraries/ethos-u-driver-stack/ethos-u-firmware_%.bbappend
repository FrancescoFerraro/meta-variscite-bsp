ETHOS_U_FIRMWARE_SRC = "git://github.com/varigit/ethos-u-firmware.git;protocol=https"
SRCBRANCH = "lf-5.15.71_2.2.0_var01"
SRCREV = "3265ff6bfe2ff3e9e6dbbb6c4d8fec73560946ed"
# FIXME: Figure out why this is needed
LIC_FILES_CHKSUM:remove = "file://LICENSE.txt;md5=e3fc50a88d0a364313df4b21ef20c29e"